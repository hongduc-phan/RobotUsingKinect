# Keil uVision project Mobile Robot.uvproj, settings and files
target Mobile Robot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mobile Robot +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\MOBILE_ROBOT;.\Src;.\User;..\STM32F10x_Lib_V3.5.0\CMSIS\CM3\CoreSupport;..\STM32F10x_Lib_V3.5.0\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: common.c main.c stm32f10x_it.c system_stm32f10x.c
  group Src
    ./Src/: control.c led.c motor.c systick.c uart.c buzzer.c adc.c flash.c input.c
  group SYS
    ../STM32F10x_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_dma.c
    ../STM32F10x_Lib_V3.5.0/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
